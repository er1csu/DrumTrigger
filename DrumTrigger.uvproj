# Keil uVision project DrumTrigger.uvproj, settings and files
target DrumTrigger (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: DrumTrigger
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c Vibration.c Vibration.h PLL.c pll.h startup.s ST7735.h ST7735.c tm4c123gh6pm.h Buttons.h Buttons.c ADCSWTrigger.h Sound.h ADCSWTrigger.c Sound.c SoundSamples.h
